# Keil uVision project Found_Car_F407ZGT6.uvprojx, settings and files
target Found_Car_F407ZGT6 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Found_Car_F407ZGT6 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./HARDWARES/Beep;./HARDWARES/control;./HARDWARES/KEY;./HARDWARES/MOTOR;./HARDWARES/OLED;./HARDWARES/pid_v;./SOTEWARES/BLUE;./SOTEWARES/menu;./SOTEWARES/xunji;./SOTEWARES/Uart;./SOTEWARES/HMI;./SOTEWARES/SU-03T;./HARDWARES/HCSR04
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group HARDWARES
    ./HARDWARES/Beep/: beep.c
    ./HARDWARES/control/: control.c
    ./HARDWARES/KEY/: key.c
    ./HARDWARES/MOTOR/: motor.c
    ./HARDWARES/OLED/: oled.c bmp.h oled.h oledfont.h
    ./HARDWARES/pid_v/: pid_v.c
    ./HARDWARES/HCSR04/: SR04.C SR04.h
  group SOFEWORES
    ./SOTEWARES/BLUE/: blue.c blue.h
    ./SOTEWARES/menu/: menu.c menu.h
    ./SOTEWARES/xunji/: xunji.c xunji.h
    ./SOTEWARES/Uart/: my_uart.c my_uart.h
    ./SOTEWARES/HMI/: HMI.c HMI.h
    ./SOTEWARES/SU-03T/: SU03T.c SU03T.h
software components: CMSIS:CORE 5.6.0
